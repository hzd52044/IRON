# Keil uVision project FM33A0XX_Tester.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.3.02
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33A0XX_Tester
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __VTOR_PRESENT,__A04,__DEBUG
  c include: ..\Drivers;..\UserCode
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\sct\fm33a0_test.sct
  group UserCode
    ../UserCode/: main.c user_init.c interrupt.c adc.c disp.c
  group stdperiph_driver
    ../Drivers/: fm33a0xx_anac.c fm33a0xx_btim.c fm33a0xx_flash.c fm33a0xx_gpio.c fm33a0xx_hspi.c fm33a0xx_i2c.c fm33a0xx_iwdt.c fm33a0xx_lcd.c fm33a0xx_lptim.c fm33a0xx_pmu.c fm33a0xx_rcc.c fm33a0xx_rtc.c fm33a0xx_scu.c fm33a0xx_spi.c fm33a0xx_uart.c fm33a0xx_wwdt.c fm33a0xx_aes.c fm33a0xx_crc.c fm33a0xx_dma.c fm33a0xx_etim.c fm33a0xx_trng.c fm33a0xx_u7816.c
    ../Device/Source/: system_FM33A0XX.c
    ../Device/Source/ARM/: startup_FM33A0XX.s
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.3.02
  cpu: as above
  output: FM33A0XX_Tester
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __VTOR_PRESENT,__A04
  c include: ..\Drivers;..\UserCode
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\sct\fm33a0_test.sct
software components: CMSIS:CORE 5.0.1
